# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\Include;..\User
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: led.c led.h keyboard.c keyboard.h ds1302.c ds1302.h onewire.c onewire.h
  group Include
    ../Include/: init.c init.h main.h
